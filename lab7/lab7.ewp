# IAR project lab7.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: driverlib_MSP430F5xx_6xx; board_hal; F5xx_F6xx_Core_Lib; fatfs; UXdemo; CTS
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: adc.c AJIOB_HAL_buffer.c AJIOB_HAL_buttons.c AJIOB_HAL_display.c AJIOB_HAL_flash.c AJIOB_HAL_timer_a.c calc_logic.c main.c sw_interrupts.c
  group board_hal
    board_hal/: HAL_Board.c HAL_Buttons.c HAL_Cma3000.c HAL_Dogs102x6.c HAL_SDCard.c HAL_Wheel.c
  group CTS
    CTS/: CTS_HAL.c CTS_Layer.c structure.c
  group driverlib
    driverlib_MSP430F5xx_6xx/: adc10_a.c adc12_a.c aes.c battbak.c comp_b.c crc.c ctsd16.c dac12_a.c dma.c eusci_a_spi.c eusci_a_uart.c eusci_b_i2c.c eusci_b_spi.c flashctl.c gpio.c lcd_b.c lcd_c.c ldopwr.c mpy32.c oa.c pmap.c pmm.c ram.c ref.c rtc_a.c rtc_b.c rtc_c.c sd24_b.c sfr.c sysctl.c tec.c timer_a.c timer_b.c timer_d.c tlv.c ucs.c usci_a_spi.c usci_a_uart.c usci_b_i2c.c usci_b_spi.c wdt_a.c
  group F5xx_F6xx_Core_Lib
    F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_PMAP.c HAL_PMM.c HAL_TLV.c HAL_UCS.c
  group fatfs
    fatfs/: ff.c mmc.c
  group UXdemo
    UXdemo/: SDCard.c
